Commit message: joint breaking issue fixed

File: urc_gazebo/urdf/Panda.urdf (robot description, URDF)
Before this commit: robot panda, 13 links, 12 joints
Links:
- added link world
Joints:
- added joint world_to_base: type fixed, parent world, child panda_link0, origin xyz=0 0 1 rpy=0 0 0
